Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-03-22T10:43:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 22 10:43:42 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\e41d791f-4670-44ba-9229-0ff3cc991bc7\65817297-f4dc-4d86-bcec-db852e698493\ifc * Database version: 5507 * Database creation date: Wed Mar 22 10:43:41 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 22 10:43:42 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 22 10:43:42 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12292340_UA_KM7174FR:26717400_UA_12292340_KM7174FR, (2)
In: Default
Type - Classification: A-KM-7000 (Uniformat); Material: z_Miele_Design_Glass Black, z_Miele_Design_Stainless Steel, z_Miele_Connection_Electric, Default, z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 26717400_UA_12292340_KM7174FR
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 26717400_UA_12292340_KM7174FR
Type - Pset_ProvisionForVoid - Width: 614 mm; Height: 51 mm; Depth: 514 mm
Pset_BuildingElementProxyCommon - sets with these values: 2
